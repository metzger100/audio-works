.subckt DUT a b
.ends DUT
